PYPI_PACKAGE = "charset_normalizer"
PV = "3.4.0"
SRC_URI[sha256sum] = "223217c3d4f82c3ac5e29032b3f1c2eb0fb591b72161f86d93f5719079dae93e"
