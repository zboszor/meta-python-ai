PV = "2.2.3"
SRC_URI[sha256sum] = "4f18ba62b61d7e192368b84517265a99b4d7ee8912f8708660fb4a366cc82667"
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
