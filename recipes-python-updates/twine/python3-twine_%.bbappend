RDEPENDS:${PN} += " \
	python3-readme-renderer \
	python3-requests \
	python3-requests-toolbelt \
	python3-urllib3 \
	python3-keyring \
	python3-rfc3986 \
	python3-rich \
	python3-packaging \
	python3-id \
"
