PV = "1.8.0"
PYPI_PACKAGE = "websocket_client"
SRC_URI[sha256sum] = "3239df9f44da632f96012472805d40a23281a991027ce11d2f45a6f24ac4c3da"
LIC_FILES_CHKSUM = "file://LICENSE;md5=320e551a762959592b7d79dd7a432b48"
