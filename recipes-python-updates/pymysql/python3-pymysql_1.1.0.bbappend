PV = "1.1.1"
SRC_URI[sha256sum] = "e127611aaf2b417403c60bf4dc570124aeb4a57f5f37b8e95ae399a42f904cd0"
PYPI_PACKAGE = "pymysql"
