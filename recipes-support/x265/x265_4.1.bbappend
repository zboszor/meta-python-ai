SRC_URI += " \
	file://0001-Fix-error-message-for-x265-check-when-StrictCbr-is-e.patch;striplevel=2 \
	file://0002-Fix-memory-leak-if-no-command-line-option.patch;striplevel=2 \
	file://0003-Fix-SEI-buffer-memory-leaks.patch;striplevel=2 \
	file://0004-Fix-shared-link-issue-R_X86_64_PC32.patch;striplevel=2 \
	file://0005-Add-check-for-input-video-resolution-exceeding-8k.patch;striplevel=2 \
	file://0006-Fix-max-supported-input-resolution-check.patch;striplevel=2 \
	file://0007-Add-Feature-flag-support-in-x265_config.patch;striplevel=2 \
	file://0008-Fix-the-buffer-size-and-frame-out-of-bound-access-is.patch;striplevel=2 \
	file://0009-Add-new-Levels.patch;striplevel=2 \
	file://0010-fix-for-yuv-recon-output-issue.patch;striplevel=2 \
	file://0011-fix-to-resolve-issue-when-rd-refine-and-dynamic-refi.patch;striplevel=2 \
	file://0012-Unroll-C-implementation-of-pelFilterChroma_V.patch;striplevel=2 \
	file://0013-Unroll-C-implementation-of-pelFilterChroma_H.patch;striplevel=2 \
"
