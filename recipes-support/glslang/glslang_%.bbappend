SYSROOT_DIRS += "${bindir}"
