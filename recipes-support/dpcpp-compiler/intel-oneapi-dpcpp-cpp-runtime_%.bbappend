SYSROOT_DIRS += "/opt"
SYSROOT_DIRS_NATIVE += "${RECIPE_SYSROOT_NATIVE}/opt"
