FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0002-THRIFT-5842-Add-missing-cstdint-include-for-int64_t.patch"
