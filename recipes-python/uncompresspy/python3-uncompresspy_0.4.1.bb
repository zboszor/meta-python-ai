SUMMARY = "Pure Python package for uncompressing LZW files (.Z), such as the ones created by Unix's shell tool compress"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7ee38e8599e83a2d3fe9d74131688d05"

PYPI_PACKAGE = "uncompresspy"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "e79ead66eaed8d42364d807c0ba3f3a8aef0e0087a9beaf1a60f23a808a6c147"
