SUMMARY = "Traceback serialization library."
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=810c4c43873f8d9331fb067a6473a960"

PYPI_PACKAGE = "tblib"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "846e274d0aeec822953251a3cbd3d840fd0ee7a5ec844d59ffbde7b056f9cd2b"
