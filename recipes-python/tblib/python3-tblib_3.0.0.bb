SUMMARY = "Traceback serialization library."
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f7dab5be9201bbd1740e561e5cee4a3c"

PYPI_PACKAGE = "tblib"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "93622790a0a29e04f0346458face1e144dc4d32f493714c6c3dff82a4adb77e6"
