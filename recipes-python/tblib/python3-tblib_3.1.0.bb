SUMMARY = "Traceback serialization library."
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f7dab5be9201bbd1740e561e5cee4a3c"

PYPI_PACKAGE = "tblib"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "06404c2c9f07f66fee2d7d6ad43accc46f9c3361714d9b8426e7f47e595cd652"
