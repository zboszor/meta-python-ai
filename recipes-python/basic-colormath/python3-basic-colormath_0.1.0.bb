SUMMARY = "Salvaged colormath"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=fa9f86711c28b5852861ea6b98c7a008"

PYPI_PACKAGE = "basic_colormath"

inherit pypi python_poetry_core
SRC_URI[sha256sum] = "f93b5a60a84e357575f5e60e647fdd9473e2ad80d941a1ea3b6751183473a73f"
