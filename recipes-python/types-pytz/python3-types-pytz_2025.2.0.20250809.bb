SUMMARY = "Typing stubs for pytz"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ec038232ab86edd7354b091c54e190e2"

PYPI_PACKAGE = "types_pytz"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "222e32e6a29bb28871f8834e8785e3801f2dc4441c715cd2082b271eecbe21e5"
