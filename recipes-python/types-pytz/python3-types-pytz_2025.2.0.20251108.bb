SUMMARY = "Typing stubs for pytz"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ec038232ab86edd7354b091c54e190e2"

PYPI_PACKAGE = "types_pytz"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "fca87917836ae843f07129567b74c1929f1870610681b4c92cb86a3df5817bdb"
