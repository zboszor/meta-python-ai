SUMMARY = "Typing stubs for pytz"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ec038232ab86edd7354b091c54e190e2"

PYPI_PACKAGE = "types_pytz"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "deda02de24f527066fc8d6a19e284ab3f3ae716a42b4adb6b40e75e408c08d36"
