RDEPENDS:${PN} += " \
	python3-astropy \
	python3-av \
	python3-imageio-ffmpeg \
	python3-pillow-heif \
	python3-psutil \
	python3-rawpy \
	python3-tifffile \
"
