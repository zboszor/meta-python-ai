SUMMARY = "Fast, Extensible Progress Meter"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4c50b6bd2e1e6481b0c7ed7691425651"

PYPI_PACKAGE = "loguru"

inherit pypi setuptools3
SRC_URI[sha256sum] = "e671a53522515f34fd406340ee968cb9ecafbc4b36c679da03c18fd8d0bd51ac"
