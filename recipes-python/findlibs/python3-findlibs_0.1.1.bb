SUMMARY = "A packages to search for shared libraries on various platforms"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

PYPI_PACKAGE = "findlibs"

inherit pypi setuptools3 cython
SRC_URI[sha256sum] = "dc7a0d4fe2bb6635f1e4bdcde60aecec42b6755c4783c2f629069c2f9321d732"
