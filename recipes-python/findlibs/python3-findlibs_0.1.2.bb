SUMMARY = "A packages to search for shared libraries on various platforms"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

PYPI_PACKAGE = "findlibs"

inherit pypi python_setuptools_build_meta cython
SRC_URI[sha256sum] = "1f56d220c69686392ebdc4c65b32ee344818bca633643a8c97592957d1728122"
