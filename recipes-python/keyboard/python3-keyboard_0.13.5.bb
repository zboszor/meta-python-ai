SUMMARY = "Hook and simulate keyboard events"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=adc1f231c76ee2f1f36025d56926ba2c"

PYPI_PACKAGE = "keyboard"
PYPI_PACKAGE_EXT = "zip"

inherit pypi setuptools3
SRC_URI[sha256sum] = "63ed83305955939ca5c9a73755e5cc43e8242263f5ad5fd3bb7e0b032f3d308b"
