SUMMARY = "Itertools and builtins for AsyncIO and mixed iterables"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f0c422eaa1f23d09f8203dc0af3e2d54"

DEPENDS = "python3-flit-core-native"

PYPI_PACKAGE = "aioitertools"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "42c68b8dd3a69c2bf7f2233bf7df4bb58b557bca5252ac02ed5187bbc67d6831"
