SUMMARY = "Itertools and builtins for AsyncIO and mixed iterables"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f0c422eaa1f23d09f8203dc0af3e2d54"

DEPENDS = "python3-flit-core-native"

PYPI_PACKAGE = "aioitertools"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "620bd241acc0bbb9ec819f1ab215866871b4bbd1f73836a55f799200ee86950c"
