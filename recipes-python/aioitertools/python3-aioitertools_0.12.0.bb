SUMMARY = "Itertools and builtins for AsyncIO and mixed iterables"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f0c422eaa1f23d09f8203dc0af3e2d54"

DEPENDS = "python3-flit-core-native"

PYPI_PACKAGE = "aioitertools"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "c2a9055b4fbb7705f561b9d86053e8af5d10cc845d22c32008c43490b2d8dd6b"
