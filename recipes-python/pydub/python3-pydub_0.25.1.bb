SUMMARY = "Manipulate audio with an simple and easy high level interface"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

PYPI_PACKAGE = "pydub"

inherit pypi setuptools3
SRC_URI[sha256sum] = "980a33ce9949cab2a569606b65674d748ecbca4f0796887fd6f46173a7b0d30f"
