SUMMARY = "The ASDF Standard schemas"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3aac1c0e2f8dd442a922172c100bc5a4"

DEPENDS = "python3-setuptools-scm-native"

PYPI_PACKAGE = "asdf_standard"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "01535bc2b15bfc09ec8a62d4999f9cf32dc49dc71660c8425640228fd8776102"
