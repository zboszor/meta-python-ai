SUMMARY = "The ASDF Standard schemas"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3aac1c0e2f8dd442a922172c100bc5a4"

DEPENDS = "python3-setuptools-scm-native"

PYPI_PACKAGE = "asdf_standard"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "0c5f121d0db87cb7780d61a087f392c5104ce208016cfb2a130c9cea912cfddc"
