SUMMARY = "The ASDF Standard schemas"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3aac1c0e2f8dd442a922172c100bc5a4"

DEPENDS = "python3-setuptools-scm-native"

PYPI_PACKAGE = "asdf_standard"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "5942caf7d143f39f72f634484373c7f40ce48571d1db3c271e13858e33fe5966"
