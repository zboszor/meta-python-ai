SUMMARY = "A heap with decrease-key and increase-key operations"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e9fff195948f5083d7359a6fce95ec27"

PYPI_PACKAGE = "HeapDict"

inherit pypi setuptools3
SRC_URI[sha256sum] = "8495f57b3e03d8e46d5f1b2cc62ca881aca392fd5cc048dc0aa2e1a6d23ecdb6"
