SUMMARY = "Read GCS, ABS and local paths with the same interface, clone of tensorflow.io.gfile"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dfb1b490080d1aae0067e35550910c4d"

PYPI_PACKAGE = "blobfile"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "32ec777414de7bb2a76ca812a838f0d33327ca28ae844a253503cde625cdf2f1"
