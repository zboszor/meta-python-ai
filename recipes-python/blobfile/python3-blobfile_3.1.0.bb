SUMMARY = "Read GCS, ABS and local paths with the same interface, clone of tensorflow.io.gfile"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=906b3f5f542bca77cd5dd18ede693457"

PYPI_PACKAGE = "blobfile"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "d45b6b1fa3b0920732314c23ddbdb4f494ca12f787c2b6eb6bba6faa51382671"
