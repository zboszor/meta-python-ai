SUMMARY = "Read GCS, ABS and local paths with the same interface, clone of tensorflow.io.gfile"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=906b3f5f542bca77cd5dd18ede693457"

PYPI_PACKAGE = "blobfile"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "78514a9265b9aa7d4607042dc77c5e6461ab27036450ad8e1f6ef9a7f29bf958"
