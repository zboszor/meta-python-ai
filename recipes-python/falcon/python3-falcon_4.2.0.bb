SUMMARY = "The Falcon Web Framework"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

PYPI_PACKAGE = "falcon"

inherit pypi python_setuptools_build_meta cython

SRC_URI[sha256sum] = "c13e86e49696d6655411fe09473c34997e49ff45e8cdf7576297b0ca71ceac3d"
