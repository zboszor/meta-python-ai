SUMMARY = "The Falcon Web Framework"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

PYPI_PACKAGE = "falcon"

inherit pypi python_setuptools_build_meta cython

SRC_URI[sha256sum] = "dbc3fa642b43e7662f121d0a7b5d7ea42a1a31fb22ae63572c42ee3ecd1f79d0"
