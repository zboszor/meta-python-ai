SUMMARY = "Typing stubs for Pillow"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=c2d9643b4523fdf462545aeb1356ad23"

PYPI_PACKAGE = "types-Pillow"

inherit pypi setuptools3
SRC_URI[sha256sum] = "559fb52a2ef991c326e4a0d20accb3bb63a7ba8d40eb493e0ecb0310ba52f0d3"
