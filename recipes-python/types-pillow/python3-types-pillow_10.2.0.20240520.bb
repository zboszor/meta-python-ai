SUMMARY = "Typing stubs for Pillow"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=ef4dc1e740f5c928f1608a4a9c7b578e"

PYPI_PACKAGE = "types-Pillow"

inherit pypi setuptools3
SRC_URI[sha256sum] = "130b979195465fa1e1676d8e81c9c7c30319e8e95b12fae945e8f0d525213107"
