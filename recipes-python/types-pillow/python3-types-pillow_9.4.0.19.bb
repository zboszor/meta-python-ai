SUMMARY = "Typing stubs for Pillow"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=ef4dc1e740f5c928f1608a4a9c7b578e"

PYPI_PACKAGE = "types-Pillow"

inherit pypi setuptools3
SRC_URI[sha256sum] = "a04401181979049977e318dae4523ab5ae8246314fc68fcf50b043ac885a5468"
