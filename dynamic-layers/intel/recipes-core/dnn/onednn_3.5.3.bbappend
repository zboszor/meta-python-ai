PV = "3.7.3"
SRCREV = "34d53b436e652c2e315a66d65bf3c79940c2c530"

EXTRA_OECMAKE:append = " \
	-DDNNL_EXPERIMENTAL_UKERNEL=ON \
	-DONEDNN_EXPERIMENTAL_GRAPH_COMPILER_BACKEND=ON \
"
